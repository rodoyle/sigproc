options:
  parameters:
    generate_options: hb_qt_gui
    id: uhd_test
    output_language: python
    title: Waterfall
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '643000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000.0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '40'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
